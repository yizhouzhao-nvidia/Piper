Commit message: turned usd

File: src/piper/teleop/asset/piper_description/urdf/piper_description.urdf (robot description, URDF)
Before this commit: robot piper, 11 links, 10 joints
Joints:
- joint joint8: mimic (none) -> joint=joint7 multiplier=-1
